# Keil uVision project active_navigation_driver_V0.01.uvprojx, settings and files
target active_navigation_driver_V0.01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C001M06B002 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o ..\OutPut\C001M06B002.bin ..\OutPut\C001M06B002.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\OS\Port;..\OS\Source;..\StLowLevelDriver\CMSIS;..\StLowLevelDriver\Lib\inc;..\StLowLevelDriver\Lib\src;..\StLowLevelDriver\StartUp;..\User\APP;..\User\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user-app
    ../User/APP/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h task_cfg.c task_cfg.h task_AdcDetect.c task_PidCalc.c task_Protocol.c task_SensorDet.c task_MotionCtrl.c task_EHandler.c task_LinearActuator.c
  group user-bsp
    ../User/BSP/: common.c common.h adc.c motor.c motor.h usart.c usart.h delay.c delay.h sys_config.h LibMd5.c adc.h LibMd5.h linear_actuator.c loadmotor.c mpu9250.c
    ../User/APP/: kalman.c
  group lib-inc
    ../StLowLevelDriver/Lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group lib-src
    ../StLowLevelDriver/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group os-port
    ../OS/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group os-src
    ../OS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group cmsis
    ../StLowLevelDriver/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group startup
    ../StLowLevelDriver/StartUp/: startup_stm32f10x_hd.s
  group doc
    ../DOC/: readme.txt
